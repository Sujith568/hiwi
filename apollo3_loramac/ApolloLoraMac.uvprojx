# Keil uVision project ApolloLoraMac.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.4.1
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blankApollo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO3 SOFT_SE REGION_EU868 ACTIVE_REGION=LORAMAC_REGION_EU868
  c include: ..\AmbiqSuite-SDK-v3-1-1\AmbiqSuite_R3.1.1\mcu\apollo3;..\AmbiqSuite-SDK-v3-1-1\AmbiqSuite_R3.1.1\utils;..\AmbiqSuite-SDK-v3-1-1\AmbiqSuite_R3.1.1\CMSIS\AmbiqMicro\Include;..\apollo3_loramac;..\Lora\boards;..\Lora\boards\Apollo3_V2;..\Lora\apps\LoRaMac\common\LmHandler\packages;..\Lora\apps\LoRaMac\common\LmHandler;..\Lora\apps\LoRaMac\common;..\Lora\mac\region;..\Lora\mac;..\Lora\peripherals;..\Lora\peripherals\soft-se;..\Lora\radio;..\Lora\system;..\Lora\boards;..\Library
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  group Project Source
    ./: main.c
  group lib
    ../AmbiqSuite-SDK-v3-1-1/AmbiqSuite_R3.1.1/mcu/apollo3/hal/: am_hal_adc.c am_hal_ble.c am_hal_ble_patch.c am_hal_ble_patch_b0.c am_hal_burst.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_cmdq.c am_hal_ctimer.c am_hal_debug.c am_hal_entropy.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_mspi.c am_hal_pdm.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_scard.c am_hal_secure_ota.c am_hal_security.c am_hal_stimer.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_uart.c am_hal_wdt.c
  group hardware Library
    ./: fuota.c periodicUplink.c
    ../Library/: adc.c am1805.c as7341.c dac63002.c i2c.c ina232.c mb85rc64ta.c shtc3.c spi.c taskhandler.c timing.c gpio.c device.c
  group hardware Lib
    ./: fuota.h periodicUplink.h
    ../Library/: pins.h adc.h am1805.h as7341.h dac63002.h i2c.h ina232.h mb85rc64ta.h rtc.h shtc3.h spi.h taskHandler.h timing.h gpio.h device.h
  group util
    ../AmbiqSuite-SDK-v3-1-1/AmbiqSuite_R3.1.1/utils/: am_util_ble.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_regdump.c am_util_stdio.c am_util_string.c am_util_time.c
  group Apollo3
    ../LoRa/boards/Apollo3_V2/: board.c eeprom-board.c gpio-board.c pinName-board.c pinName-ioe.c rtc-board.c spi-board.c sx126x-board.c transmitConfig.h utilities.c
    ../LoRa/boards/: board.h eeprom-board.h gpio-board.h pinName-board.h pinName-ioe.h rtc-board.h spi-board.h sx126x-board.h utilities.h
  group mac
    ../LoRa/mac/: LoRaMac.c LoRaMac.h LoRaMacAdr.c LoRaMacAdr.h LoRaMacClassB.c LoRaMacClassB.h LoRaMacCommands.c LoRaMacCommands.h LoRaMacConfirmQueue.c LoRaMacConfirmQueue.h LoRaMacCrypto.c LoRaMacCrypto.h LoRaMacParser.c LoRaMacParser.h LoRaMacSerializer.c LoRaMacSerializer.h LoRaMacClassBConfig.h LoRaMacClassBNvm.h LoRaMacCryptoNvm.h LoRaMacHeaderTypes.h LoRaMacMessageTypes.h LoRaMacTest.h LoRaMacTypes.h secure-element.h secure-element-nvm.h
  group region
    ../LoRa/mac/region/: Region.c Region.h RegionCommon.c RegionCommon.h RegionEU433.c RegionEU433.h RegionEU868.c RegionEU868.h RegionNvm.h
  group peripherals
    ../LoRa/peripherals/soft-se/: aes.c aes.h cmac.c cmac.h soft-se.c soft-se-hal.c soft-se-hal.h se-identity.h
  group radio
    ../LoRa/radio/: radio.c radio.h sx126x.c sx126x.h
  group system
    ../LoRa/system/: delay.c delay.h systime.c systime.h timer.c timer.h nvmm.c nvmm.h uart.c uart.h
  group LoRaMac
    ./: JalapenosLpp.c JalapenosLpp.h
    ../LoRa/apps/LoRaMac/common/: CayenneLpp.c CayenneLpp.h cli.c cli.h Commissioning.h githubVersion.h LmHandlerMsgDisplay.c LmHandlerMsgDisplay.h NvmDataMgmt.c NvmDataMgmt.h
    ../LoRa/apps/LoRaMac/common/LmHandler/: LmHandler.c LmHandler.h LmHandlerTypes.h
    ../LoRa/apps/LoRaMac/common/LmHandler/packages/: FragDecoder.c FragDecoder.h LmhPackage.h LmhpClockSync.c LmhpClockSync.h LmhpCompliance.c LmhpCompliance.h LmhpFragmentation.c LmhpFragmentation.h LmhpRemoteMcastSetup.c LmhpRemoteMcastSetup.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2, Device:Startup 1.3.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
