# Keil uVision project ApolloFirmware.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.4.1
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ApolloFirmware
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO3
  c include: D:\programs\Ambiq\AmbiqSuite_R3.0.0\AmbiqSuite_R3.0.0\mcu\apollo3;D:\programs\Ambiq\AmbiqSuite_R3.0.0\AmbiqSuite_R3.0.0\utils;D:\programs\Ambiq\AmbiqSuite_R3.0.0\AmbiqSuite_R3.0.0\CMSIS\AmbiqMicro\Include;..\Library
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  group src
    ./: pinAssignment.h main.c
  group lib
    D:/programs/Ambiq/AmbiqSuite_R3.0.0/AmbiqSuite_R3.0.0/mcu/apollo3/hal/: am_hal_adc.c am_hal_ble.c am_hal_ble_patch.c am_hal_ble_patch_b0.c am_hal_burst.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_cmdq.c am_hal_ctimer.c am_hal_debug.c am_hal_entropy.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_mspi.c am_hal_pdm.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_scard.c am_hal_secure_ota.c am_hal_security.c am_hal_stimer.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_uart.c am_hal_wdt.c
  group Apollo src
    ../Library/: adc.c am1805.c as7341.c dac63002.c device.c gpio.c i2c.c mb85rc64ta.c shtc3.c spi.c timing.c rtc.c taskhandler.c
  group Apollo lib
    ../Library/: adc.h am1805.h as7341.h dac63002.h device.h gpio.h i2c.h mb85rc64ta.h pins.h shtc3.h spi.h timing.h rtc.h taskHandler.h
  group util
    D:/programs/Ambiq/AmbiqSuite_R3.0.0/AmbiqSuite_R3.0.0/utils/: am_util_ble.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_regdump.c am_util_stdio.c am_util_string.c am_util_time.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2, Device:Startup 1.3.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
